## config/boards/shields/creepyboard/Kconfig.defconfig
```kconfig
if SHIELD_CREEPYBOARD

config ZMK_KEYBOARD_NAME
    default "creepyboard"

config ZMK_STUDIO
    default y

endif
```
